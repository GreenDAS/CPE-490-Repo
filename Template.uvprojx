# Keil uVision project Template.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c startup_stm32l476xx.s _init_.h _init_.c gpio_lib.c gpio_lib.h timer_lib.c timer_lib.h interupt_lib.c interupt_lib.h lcd_routines.c lcd_routines.h lcd_lib.c lcd_lib.h interupt_handlers.c string_lib.c string_lib.h globals.c globals.h pid.c pid.h pwm_lib.c pwm_lib.h RTOS.c RTOS.h Timekeeper.c Timekeeper.h
software components: CMSIS:CORE 6.1.0
